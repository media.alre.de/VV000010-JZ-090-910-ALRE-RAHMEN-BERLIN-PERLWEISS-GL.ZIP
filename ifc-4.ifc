Properties of the parts of a building model (IFC4)

# File
Description: alre-Rahmen, 50 x 50, perlweiß (RAL1013), glänzend, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: VV000010, alre-Rahmen, 50 x 50, perlweiß (RAL1013), glänzend
In: Raum
Description: alre-Rahmen „Berlin“ für alle UP-Geräte mit Abdeckung 50 x 50, perlweiß (RAL1013), glänzend; Classification: EC000007 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: VV000010; ModelLabel: JZ-090.910; GlobalTradeItemNumber: 4050528063588; ProductURL: https://alre.de/produkt_VV000010
Pset_Specification - NominalLength: 0.085 m; NominalWidth: 0.081 m; NominalDepth: 0.01 m; NetWeight: 0.024
Pset_ALRE_ETIM_Properties - Farbe: weiß; Breite: 81; Halogenfrei: yes; Höhe: 85; Tiefe: 10; Werkstoffgüte: Thermoplast; Werkstoff: Kunststoff; RAL-Nummer (ähnlich): 1013; Ausführung der Oberfläche: glänzend; ETIM-Klasse: EC000007; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-VV000010.pdf
